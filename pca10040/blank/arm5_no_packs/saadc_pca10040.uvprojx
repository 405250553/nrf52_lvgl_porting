# Keil uVision project saadc_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths --diag_suppress=188,68,546,111,870
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config;../../../../../../components/libraries/fifo;../../../../../../components/libraries/uart;..\..\..\lvgl;..\..\..\lvgl\lvgl_port;..\..\..\lvgl\lvgl_driver;..\..\..\lvgl\lvgl_driver\src;..\..\..\lvgl\lvgl_app;..\..\..\..\..\..\components\libraries\gfx
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_ppi.c nrf_drv_uart.c nrf_drv_spi.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_ppi.c nrfx_saadc.c nrfx_timer.c nrfx_uart.c nrfx_uarte.c nrfx_gpiote.c nrfx_spi.c nrfx_spim.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../: ili9341.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group lvgl_Port
    ../../../lvgl/lvgl_port/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl_App
    ../../../lvgl/lvgl_app/widgets/label/: lv_example_label_1.c
    ../../../lvgl/lvgl_app/widgets/chart/: lv_example_chart_1.c
    ../../../lvgl/lvgl_app/widgets/calendar/: lv_example_calendar_1.c
  group lvgl_Drivers
    ../../../lvgl/lvgl_driver/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../lvgl/lvgl_driver/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../lvgl/lvgl_driver/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../lvgl/lvgl_driver/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../lvgl/lvgl_driver/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../lvgl/lvgl_driver/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../lvgl/lvgl_driver/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../../../lvgl/lvgl_driver/src/extra/: lv_extra.c
    ../../../lvgl/lvgl_driver/src/extra/layouts/flex/: lv_flex.c
    ../../../lvgl/lvgl_driver/src/extra/layouts/grid/: lv_grid.c
    ../../../lvgl/lvgl_driver/src/extra/libs/bmp/: lv_bmp.c
    ../../../lvgl/lvgl_driver/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../lvgl/lvgl_driver/src/extra/libs/freetype/: lv_freetype.c
    ../../../lvgl/lvgl_driver/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../lvgl/lvgl_driver/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../lvgl/lvgl_driver/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../lvgl/lvgl_driver/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../lvgl/lvgl_driver/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../lvgl/lvgl_driver/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../lvgl/lvgl_driver/src/extra/others/gridnav/: lv_gridnav.c
    ../../../lvgl/lvgl_driver/src/extra/others/monkey/: lv_monkey.c
    ../../../lvgl/lvgl_driver/src/extra/others/snapshot/: lv_snapshot.c
    ../../../lvgl/lvgl_driver/src/extra/themes/basic/: lv_theme_basic.c
    ../../../lvgl/lvgl_driver/src/extra/themes/default/: lv_theme_default.c
    ../../../lvgl/lvgl_driver/src/extra/themes/mono/: lv_theme_mono.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/animimg/: lv_animimg.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/chart/: lv_chart.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/led/: lv_led.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/list/: lv_list.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/menu/: lv_menu.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/meter/: lv_meter.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/span/: lv_span.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/spinner/: lv_spinner.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/tabview/: lv_tabview.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/tileview/: lv_tileview.c
    ../../../lvgl/lvgl_driver/src/extra/widgets/win/: lv_win.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
